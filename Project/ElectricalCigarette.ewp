# IAR project ElectricalCigarette.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ElectricalCigarette.hex
  ILINK.IlinkOutputFile: ElectricalCigarette.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  group FWlib
    ../FWlib/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_itc.c stm8s_tim1.c stm8s_tim2.c
  group USER
    ../USER/: atomizer.c delay.c led.c main.c MIC.c motor.c power.c stm8s_interruput.c
